# Keil uVision project HC89F30xB_Touch_Low_Power_Demo_Code.uvproj, settings and files
target HC89F30xB_Touch_Low_Power_Demo_Code (MCS-51)
  device: YX23F01C YX-LINK
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(32000000)
  output: HC89F30xB_Touch_Low_Power_Demo_Code +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Application;..\..\User\INC;..\..\Libraries
  group HC51_STARTUP
    ../../User/: STARTUP.A51
  group USER
    ../../User/: Main.c
    ../../Application/Fun_Handle/: Fun_Handle.c
    ../../Application/TIMER/: TIMER.c
    ../../Application/WDT/: WDT.c
    ../../User/C/: WORK.c
  group Touch_Lib
    ../../Libraries/HC89F30xB_GeneralKey_Touch_Lib_V1.04/: HC89F30xB_GeneralKey_Touch_Lib_CFG.c HC89F30xB_GeneralKey_Touch_Filter.c HC89F30xB_GeneralKey_Touch_Multibutton.c HC89F30xB_GeneralKey_Touch_Lib_V1.04.LIB
  group TouchUartDebug_Lib
    ../../Libraries/HC89F30xB_TouchUartDebug_Lib_V1.00/: HC89F30xB_TouchUartDebug_Lib_CFG.c HC89F30xB_TouchUartDebug_Lib_V1.00.LIB
  group Included HC Driver
    ../../User/C/: HC89F30xB_IO_INIT.c HC89F30xB_ISR.c HC89F30xB_PORT_MAP.c HC89F30xB_SYS.c HC_Delay.c
  group ReadMe
    ../../: ReadMe.txt
