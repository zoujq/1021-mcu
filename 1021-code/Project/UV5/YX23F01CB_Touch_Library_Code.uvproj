# Keil uVision project YX23F01CB_Touch_Library_Code.uvproj, settings and files
target YX23F01CB_Touch_Library_Code (MCS-51)
  device: YX23F01C YX-LINK
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(32000000)
  output: YX23F01CB_Touch_Library_Code +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Application;..\..\User\INC;..\..\Libraries
  group HC51_STARTUP
    ../../User/: STARTUP.A51
  group USER
    ../../User/: Main.c
    ../../User/C/: delay.c printf_c.c
  group Touch_Lib
    ../../Libraries/YX23F01CB_GeneralKey_Touch_Lib_V1.04/: YX23F01CB_GeneralKey_Touch_Lib_CFG.c YX23F01CB_GeneralKey_Touch_Filter.c YX23F01CB_GeneralKey_Touch_Multibutton.c YX23F01CB_GeneralKey_Touch_Lib_V1.04.LIB
  group TouchUartDebug_Lib
    ../../Libraries/YX23F01CB_TouchUartDebug_Lib_V1.00/: YX23F01CB_TouchUartDebug_Lib_CFG.c YX23F01CB_TouchUartDebug_Lib_V1.00.LIB
  group Included HC Driver
    ../../User/C/: YX23F01CB_IO_INIT.c YX23F01CB_ISR.c YX23F01CB_PORT_MAP.c YX23F01CB_SYS.c
